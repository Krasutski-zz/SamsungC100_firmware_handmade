# IAR project c100_firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\Drivers\cx805_hal\inc; ..\Drivers\cx20524; ..\App; ..\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c100.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: cx805_mem_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: cx805_vect.s
    ../: main.c
  group app/logger
    ../App/logger/: logger.c logger.h
  group bsp
    ../bsp/: bsp.c bsp.h clocks.c clocks.h gpio.c gpio.h uart.c uart.h
  group Drivers/CX20524_PMU
    ../Drivers/cx20524/: cx20524.c cx20524.h
  group Drivers/HAL/inc
    ../Drivers/cx805_hal/inc/: cx805.h cx805_clk.h cx805_gpio.h cx805_hal.h cx805_uart.h
  group Drivers/HAL/src
    ../Drivers/cx805_hal/src/: cx805_clk.c cx805_gpio.c cx805_i2c.c cx805_uart.c
